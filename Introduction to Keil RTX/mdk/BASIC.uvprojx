# Keil uVision project BASIC.uvprojx, settings and files
target BASIC Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: LEDS-SIGNALS-UART.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, SERIAL_PORT_TYPE_UART=1,PRINTF_FLOAT_ENABLE=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/MK64F12/drivers;..;../../../../../../devices/MK64F12/utilities;../../../..;../../../../../../devices/MK64F12
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../../devices/MK64F12/arm/: startup_MK64F12.s
    ../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK64F12/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c fsl_adc16.c fsl_adc16.h fsl_pdb.c fsl_pdb.h
  group source
    ../: main.c ELEC422.C ELEC422.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
target BASIC Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: gpio_input_interrupt.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VMD12, FRDM_K64F, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:CMSIS:MK64F12_header 1.0.0
